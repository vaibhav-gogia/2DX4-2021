# Keil uVision project Lab3M1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3M1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: Mile1.s
    ../Studios/Week 4/Session 0/Studio W2-01/Studio W2-0/: PLL.c SysTick.c
software components: CMSIS:CORE 5.4.0
